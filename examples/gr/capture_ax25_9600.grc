options:
  parameters:
    author: Thomas Habets <thomas@habets.se>
    generate_options: qt_gui
    id: aprs_capture_test
    output_language: python
    title: aprs_capture_test
  states: {}

blocks:
- name: deci
  id: variable
  parameters:
    value: '20'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '144390000'
  states: {}
- name: igain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '0.7'
  states: {}
- name: ofs
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: aprs_capture_test.c32
    type: complex
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: ofs
    decim: deci
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,12500,1000)
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/deci
    fc: freq
    fftsize: '1024'
    name: '"Air"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq-ofs
    gain0: igain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [freq_xlating_fft_filter_ccc_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
